# Keil uVision project 0401.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: 0401 +hex
  AfterMake: "C:\EZ USB 8051 V1.13(ver I).exe"
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
